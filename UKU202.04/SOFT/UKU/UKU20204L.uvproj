# Keil uVision project UKU20204L.uvproj, settings and files
target Release (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: UKU20201_01 +hex
  c flags: Optim=1
  c define: UKU_VERSION=300
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group HTTP
    ./Web/: Web.inp ringin.wav index.htm
    ../Победа/UKU_Control/UKU_Control/output/: UKU_202-04-L.jar
  group Startup
    ./: startup_LPC17xx.s Net_Config.c Net_Config_HTTP.c
  group Core Code
    ./: core_cm3.c
  group System Code
    ./: system_LPC17xx.c timer.c
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib
    C:/Keil/ARM/Boards/Keil/MCB1700/RL/TCPnet/Library/: EMAC_LPC17xx.c
    ./: 25lc640.c lcd_agm1232_uku203.c simbols.c ret.c beep.c common_func.c gran.c graphic.c cmd.c
  group Sources
    ./: main.c avar.c control.c eeprom_map.c memo.c SNMP_MIB.c snmp_data_file.c
    ./Web/: Web.c
  group Interfaces
    ./: uart0.c full_can.c
target Simulator (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU20201_01
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Release Main (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU20201_01 +hex
  c flags: Optim=1
  c define: UKU_VERSION=300
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Release Stend (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU20201_01 +hex
  c flags: Optim=1
  c define: NEW_MOSKOW_BPS, UKU_VERSION=300
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target MK+LAN (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU20201_01 +hex
  c flags: Optim=1
  c define: UKU_VERSION=300
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target MK+LAN+HTTP (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU20204mk +hex
  c flags: Optim=4
  c define: UKU_VERSION=900
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target MS48+LAN+HTTP (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU20204_MS48L +hex
  c flags: Optim=2
  c define: UKU_VERSION=300, NEW_MOSKOW_BPS, MS48L
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target MS24+LAN+HTTP (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU20204_MS24L +hex
  c flags: Optim=2
  c define: UKU_VERSION=300, NEW_MOSKOW_BPS, MS24L, _24_
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target MS48+(LAN+HTTP)_OFF (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU20204_MS +hex
  c flags: Optim=2
  c define: UKU_VERSION=300, NEW_MOSKOW_BPS, MS48L, LAN_OFF
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target MK24+LAN+HTTP (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU20204_MK24L +hex
  c flags: Optim=4
  c define: UKU_VERSION=900, _24_
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target MK24 (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU20204_MK24 +hex
  c flags: Optim=4
  c define: UKU_VERSION=900, _24_, LAN_OFF
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target MK (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU20204_MK +hex
  c flags: Optim=4
  c define: UKU_VERSION=900, LAN_OFF
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target MS24 (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU20204_MS24 +hex
  c flags: Optim=2
  c define: UKU_VERSION=300, NEW_MOSKOW_BPS, MS24L, _24_,LAN_OFF
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target MK36+LAN+HTTP (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU20204_MK24L +hex
  c flags: Optim=4
  c define: UKU_VERSION=900, _36_
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
