# Keil uVision project FAT31_1.uvproj, settings and files
target FAT31_1 (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: FAT31_1 +hex
  c flags: Optim=1
  c define: UKU_VERSION=900
  c include: ..\common\inc
  asm include: ..\common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup
    ./: startup_LPC17xx.s
  group Core Code
    ./: core_cm3.c
  group System Code
    ./: system_LPC17xx.c
  group Sources
    ./: main.c gran.c cmd.c
  group Interfaces
    ./: uart0.c full_can.c power_cnt.c
target 3wire_20pos (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: FAT31_3_20 +hex
  c flags: Optim=1
  c define: VENT_3WIRE
  c include: ..\common\inc
  asm include: ..\common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
target 2wire_20pos (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: FAT31_2_20 +hex
  c flags: Optim=1
  c define: VENT_2WIRE
  c include: ..\common\inc
  asm include: ..\common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
