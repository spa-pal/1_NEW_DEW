# Keil uVision project UKU_UPS_1766.uvproj, settings and files
target UKU207_1766 (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: UKU_UPS_1766 +hex
  c flags: Optim=1
  c include: C:\Keil\ARM\RV31\INC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ./: startup_LPC17xx.s Net_Config_HTTP.c
  group Core Code
    ./: core_cm3.c
  group System code
    ./: system_LPC17xx.c
  group Code source
    ./: main.c ports_operations.c button_action.c cmd.h eeprom_map.c control.c gran.c memo.c avar_hndl.c snmp_data_file.c
  group Drivers
    ./: button_drv.c ind_drv.c beeper_drv.c 25lc640.c full_can.c led_break_drv.c ssd1306.c 24c01.c i2c.c
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib
    C:/Keil/ARM/Boards/Keil/MCB1700/RL/TCPnet/Library/: EMAC_LPC17xx.c
    ./: SNMP_MIB.c
target IBP2000_48 (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: IBP_2000_48 +hex
  c flags: Optim=1
  c define: BAT48
  c include: C:\Keil\ARM\RV31\INC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
